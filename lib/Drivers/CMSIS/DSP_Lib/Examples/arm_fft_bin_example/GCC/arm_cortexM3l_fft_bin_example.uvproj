# Keil uVision project arm_cortexM3l_fft_bin_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: arm_cortexM3l_fft_bin_example
  group Source Group 1
    ../: arm_fft_bin_data.c arm_fft_bin_example_f32.c
  group CMSIS Device
    ../../Common/: system_ARMCM3.c
    ../../Common/GCC/: startup_ARMCM3.S
