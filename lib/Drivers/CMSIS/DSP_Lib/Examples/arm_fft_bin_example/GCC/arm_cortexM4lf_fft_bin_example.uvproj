# Keil uVision project arm_cortexM4lf_fft_bin_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: arm_cortexM4lf_fft_bin_example
  group Source Group 1
    ../: arm_fft_bin_data.c arm_fft_bin_example_f32.c
  group CMSIS Device
    ../../Common/: system_ARMCM4.c
    ../../Common/GCC/: startup_ARMCM4.S
