# Keil uVision project arm_cortexM0l_fft_bin_example.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: arm_cortexM0l_fft_bin_example
  group Source Group 1
    ../: arm_fft_bin_example_f32.c arm_fft_bin_data.c
  group CMSIS Device
    ../../Common/: system_ARMCM0.c
    ../../Common/GCC/: startup_ARMCM0.S
